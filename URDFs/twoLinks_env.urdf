Commit message: changed the code to allow for symbolic environmental parameters, added test urdf and test for direct dyamics

File: URDFs/twoLinks_env.urdf (robot description, URDF)
Before this commit: robot twoLinks, 3 links, 2 joints
Links:
- link link1: mass 1 -> envvar_1
